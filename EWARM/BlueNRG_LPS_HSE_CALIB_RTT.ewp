# IAR project BlueNRG_LPS_HSE_CALIB_RTT.ewp, settings and files
configuration BlueNRG_LPS_HSE_CALIB_RTT (ARM)
  General.OGChipSelectEditMenu: BlueNRG-332 ST BlueNRG-332
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB012V1; CONFIG_DEVICE_BLUENRG_LPS; CONFIG_HW_SMPS_10uH; CONFIG_HW_LS_XTAL; BLE_STACK_CUSTOM_CONF; SUPPRESS_CONFIG_HW_WARNINGS
  ICCARM.CCIncludePath2: ..\Inc; ..\Config; ..\Drivers/Peripherals_Drivers/Inc; ..\Drivers/CMSIS/Device/ST/BlueNRG_LP/Include; ..\Drivers/CMSIS/Include; ..\Middlewares/ST/hal/Inc; ..\Middlewares\ST\PKAMGR\Inc; ..\Middlewares\ST\RNGMGR\Inc; ..\Middlewares\ST\AESMGR\Inc; ..\Middlewares/ST/BLECNTR/Inc; ..\Middlewares/ST/Bluetooth_LE/Inc; ..\Middlewares/ST/BLE_Application/layers_inc; ..\Middlewares/ST/BLE_Application/Profiles/Inc; ..\Middlewares/ST/NVMDB/Inc; ..\Drivers/BSP/Inc; ..\Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\Drivers/BSP/Components/lps22hh_STdC/driver; ..\Middlewares/ST/cryptolib/Inc; ..\Middlewares/ST/cryptolib/Inc/Common; ..\Middlewares/ST/cryptolib/Inc/AES
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BlueNRG_LPS_HSE_CALIB_RTT.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BlueNRG_LPS_HSE_CALIB_RTT.bin"
  ILINK.IlinkOutputFile: BlueNRG_LPS_HSE_CALIB_RTT.out
  ILINK.IlinkIcfFile: BlueNRG_LPS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/RTT
    ../Src/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group Application/User
    ../Src/: main.c rf_device_it.c
  group Drivers/BSP
    ../Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: startup_BlueNRG_LP.c system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7c.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c
  group Middlewares/AES
    ../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../Middlewares/ST/Bluetooth_LE/library/: libbluenrg_lp_stack.a
    ../Middlewares/ST/Bluetooth_LE/src/: stack_cns_api_stubs.c stack_user_cfg.c
  group Middlewares/BLECNTR
    ../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/HAL
    ../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lps.c
  group Middlewares/Profiles
    ../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    ../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
